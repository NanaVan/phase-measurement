options:
  parameters:
    author: nana_van
    generate_options: qt_gui
    id: step_b
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: phase_delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    start: '-math.pi'
    step: math.pi/50
    stop: math.pi
    value: '0'
  states: {}
- name: point_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '2100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0.1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: int
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: phase_delay
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: point_size
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: point_size
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Python Block to change signal 0 to signal 1 based on the pulse"""

          def __init__(self):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Signal Switch',   # will show up in GRC
                  in_sig=[np.complex64,np.complex64,np.int32],
                  out_sig=[np.complex64]
              )
              

          def work(self, input_items, output_items):
              """pulse 1: signal 0 on, signal 1 off; pulse -1: signal 0 off, signal 1 off"""
              if input_items[2][0] == 1:
                  output_items[0][:] = input_items[0]
              else:
                  output_items[0][:] = input_items[1]
              return len(output_items[0])
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: point_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(point_size)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: point_size
    gui_hint: 'tabs@0: 0,0'
    type: complex
    ymax: '50'
    ymin: '-30'
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 'tabs@1: 0,0'
    ncols: point_size
    nrows: '256'
    samp_rate: samp_rate
    type: float
    x_end_value: samp_rate/2e3
    x_label: '"Frequency (kHz)"'
    x_start_value: '-samp_rate/2e3'
    y_end_value: '0'
    y_label: '"Time (s)"'
    y_start_value: 256*point_size/samp_rate
    zmax: '500000'
    zmin: '20000'
  states: {}
- name: qtgui_time_raster_sink_x_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 'tabs@1: 1,0'
    ncols: point_size
    nrows: '256'
    samp_rate: samp_rate
    type: float
    x_end_value: samp_rate/2e3
    x_label: '"Frequency (kHz)"'
    x_start_value: '-samp_rate/2e3'
    y_end_value: '0'
    y_label: '"Time [s]"'
    y_start_value: 256*point_size/samp_rate
    zmax: 2*math.pi
    zmin: '-2*math.pi'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: point_size
    gui_hint: 'tabs@0: 1,0'
    int_max: '60'
    int_min: '0'
    type: complex
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,10,1
    label0: FFT
    label1: Mag/Phase
    num_tabs: '2'
  states: {}
- name: x_correlation_0
  id: x_correlation
  parameters:
    point_size: '1024'
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_0, '0']
- [analog_sig_source_x_0_0, '0', epy_block_0, '1']
- [analog_sig_source_x_1, '0', epy_block_0, '2']
- [blocks_complex_to_magphase_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_raster_sink_x_0_0, '0']
- [blocks_phase_shift_0, '0', x_correlation_0, '1']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_phase_shift_0, '0']
- [blocks_throttle2_0, '0', x_correlation_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_magphase_0, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [x_correlation_0, '0', blocks_stream_to_vector_0, '0']
- [x_correlation_0, '0', qtgui_freq_sink_x_0, '0']
- [x_correlation_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
