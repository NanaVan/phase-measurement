options:
  parameters:
    author: nana_van
    generate_options: qt_gui
    id: step_b_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bin_freq
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate/2'
    step: samp_rate/point_size
    stop: samp_rate/2
    value: '0'
    widget: eng_slider
  states: {}
- name: phase_delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,8
    start: '-np.pi'
    step: np.pi/50
    stop: np.pi
    value: '0'
  states: {}
- name: point_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: signal_switch
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 0,9,1,1
    initPressed: 'False'
    label: Decay on
    pressed: '1'
    released: '0'
    type: real
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '2100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: bin_select
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import numpy as np

      def select_binNum(samp_rate, point_size, freq):
          freq_range = np.linspace(-samp_rate/2, samp_rate/2, num=point_size)
          bin_num = np.searchsorted(freq_range, freq, side='left')
          if bin_num >= len(freq_range):
              bin_num -= 1
          bin_num = point_size - bin_num
          return bin_num
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: bin_select.select_binNum(samp_rate, point_size, bin_freq)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: int(not bool(signal_switch))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: signal_switch
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(1j * phase_delay)
    type: complex
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: phase_delay
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: point_size
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: point_size
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: point_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(point_size)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: point_size
    gui_hint: 'tabs@0: 0,0'
    type: complex
    ymax: '150'
    ymin: '-80'
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 'tabs@1: 0,0'
    ncols: point_size
    nrows: '256'
    samp_rate: samp_rate
    type: float
    x_end_value: samp_rate/2e3
    x_label: '"Frequency (kHz)"'
    x_start_value: '-samp_rate/2e3'
    y_end_value: '0'
    y_label: '"Time (s)"'
    y_start_value: 256*point_size/samp_rate
    zmax: 2e9
    zmin: '0'
  states: {}
- name: qtgui_time_raster_sink_x_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 'tabs@1: 1,0'
    ncols: point_size
    nrows: '256'
    samp_rate: samp_rate
    type: float
    x_end_value: samp_rate/2e3
    x_label: '"Frequency (kHz)"'
    x_start_value: '-samp_rate/2e3'
    y_end_value: '0'
    y_label: '"Time [s]"'
    y_start_value: 256*point_size/samp_rate
    zmax: 2*np.pi
    zmin: '-2*np.pi'
  states: {}
- name: qtgui_time_raster_sink_x_0_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 'tabs@2: 0,0'
    ncols: point_size
    nrows: '256'
    samp_rate: samp_rate
    type: float
    x_end_value: samp_rate/2e3
    x_label: '"Frequency (kHz)"'
    x_start_value: '-samp_rate/2e3'
    y_end_value: '0'
    y_label: '"Time [s]"'
    y_start_value: 256*point_size/samp_rate
    zmax: 2*np.pi
    zmin: '-2*np.pi'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@2:1,0
    size: '256'
    srate: samp_rate/point_size
    type: float
    ymax: '6'
    ymin: '-6'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: point_size
    gui_hint: 'tabs@0: 1,0'
    int_max: '240'
    int_min: '0'
    type: complex
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,10,10
    label0: FFT
    label1: Mag/Phase
    label2: Phase/bin
    num_tabs: '3'
  states: {}
- name: x_correlation_0
  id: x_correlation
  parameters:
    point_size: point_size
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_complex_to_magphase_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_delay_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_raster_sink_x_0_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_raster_sink_x_0_0_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1, '0', x_correlation_0, '1']
- [blocks_phase_shift_0, '0', x_correlation_0, '1']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_throttle2_0, '0', blocks_phase_shift_0, '0']
- [blocks_throttle2_0, '0', x_correlation_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_magphase_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [x_correlation_0, '0', blocks_stream_to_vector_0, '0']
- [x_correlation_0, '0', qtgui_freq_sink_x_0, '0']
- [x_correlation_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
