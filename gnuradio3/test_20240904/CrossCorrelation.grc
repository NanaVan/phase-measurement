options:
  parameters:
    generate_options: hb
    id: x_correlation
    output_language: python
    title: Cross Correlation
  states: {}

blocks:
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: point_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: point_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_1
  id: blocks_stream_to_vector
  parameters:
    num_items: point_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: point_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: point_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_1_1
  id: blocks_vector_to_stream
  parameters:
    num_items: point_size
    type: complex
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: point_size
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(point_size)
  states: {}
- name: fft_vxx_1_0
  id: fft_vxx
  parameters:
    fft_size: point_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(point_size)
  states: {}
- name: fft_vxx_1_0_0
  id: fft_vxx
  parameters:
    fft_size: point_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(point_size)
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: point_size
  id: parameter
  parameters:
    label: Calculation Size
    type: intx
    value: '1024'
  states: {}

connections:
- [blocks_multiply_conjugate_cc_0, '0', blocks_stream_to_vector_1_0, '0']
- [blocks_stream_to_vector_1_0, '0', fft_vxx_1, '0']
- [blocks_stream_to_vector_1_0_0, '0', fft_vxx_1_0, '0']
- [blocks_stream_to_vector_1_1, '0', fft_vxx_1_0_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_vector_to_stream_1_1, '0', pad_sink_2, '0']
- [fft_vxx_1, '0', blocks_vector_to_stream_1_1, '0']
- [fft_vxx_1_0, '0', blocks_vector_to_stream_1_0, '0']
- [fft_vxx_1_0_0, '0', blocks_vector_to_stream_1, '0']
- [pad_source_0, '0', blocks_stream_to_vector_1_1, '0']
- [pad_source_1, '0', blocks_stream_to_vector_1_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
